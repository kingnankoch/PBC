# Keil uVision project 1-1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C5115 Atmel
  cpu: IRAM(0 - 0xFF) XRAM(0 - 0xFF) IROM(0 - 0x3FFF) CLOCK(40000000) MODP2
  output: 1-1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 1-1.c
